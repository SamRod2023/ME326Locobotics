Commit message: final code

File: me326_final_project/model/red_cube.urdf (robot description, URDF)
Before this commit: robot red_cube, 1 links, 0 joints
Links:
- link my_box: mass 0.5 -> 0.005
